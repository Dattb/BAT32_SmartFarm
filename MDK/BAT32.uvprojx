# Keil uVision project BAT32.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: BAT32G139GK48FA Cmsemicon
  pack: Cmsemicon.BAT32G139.1.00.00
  cpu: IRAM(0x20000000,0x08000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BAT32
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Driver\inc;..\USER;..\MDK;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ../USER/: main.c Ringbuffer.c RD_init.c RD_init.h modbus_rtu.c modbus_rtu.h ai7688.c ai7688.h
  group Driver
    ../Driver/src/: sci.c clk.c flash.c flash_user.c gpio.c intp.c intp_user.c sci_user.c wdt.c wdt_user.c retarget.c timm.c timm_user.c
software components: CMSIS:CORE 5.5.0, Device:ISR 1.0.0, Device:Startup 1.0.0
